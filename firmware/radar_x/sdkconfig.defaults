## firmware/radar_x/sdkconfig.defaults
```kconfig
CONFIG_FREERTOS_HZ=100
CONFIG_FREERTOS_UNICORE=n
CONFIG_ESP_MAIN_TASK_AFFINITY_CPU0=y
CONFIG_ESP_MAIN_TASK_STACK_SIZE=8192
```
